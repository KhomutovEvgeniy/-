# Keil uVision project dummy.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: dummy +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F103xB, USE_FULL_ASSERT, USE_STDPERIPH_DRIVER, STM32F10X_MD, HSE_VALUE=8000000
  c include: .\src\cmsis;.\src;.\src\mcu_support_package\inc;.\src\spl\inc;.\src\spl
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group main
    ./src/main/: main.c
  group mcu_support_package
    ./src/mcu_support_package/: system_stm32f10x.c
    ./src/mcu_support_package/arm/: startup_stm32f103xb.s
  group spl
    ./src/spl/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_adc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_exti.c
software components: CMSIS:CORE 5.1.1
