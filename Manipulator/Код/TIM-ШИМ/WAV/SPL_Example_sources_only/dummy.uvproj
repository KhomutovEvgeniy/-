# Keil uVision project dummy.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: dummy
  c flags: Optim=1 wLevel=2
  c define: USE_FULL_ASSERT USE_STDPERIPH_DRIVER
  c misc: --c99 --feedback=unused
  c include: .\src\CMSIS;.\src\SPL\inc;.\src
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --feedback=unused
  group Startup
    ./: startup_stm32f10x_md.s
    ./src/CMSIS/: system_stm32f10x.c
  group Main
    ./src/App/: main.c
  group SPL
    ./src/SPL/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c
