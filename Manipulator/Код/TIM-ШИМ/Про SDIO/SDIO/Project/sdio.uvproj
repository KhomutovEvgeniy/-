# Keil uVision project sdio.uvproj, settings and files
target STM32 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: sdio
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\SPL;..\Source;..\SD
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group StartUp
    ./: startup_stm32f10x_hd.s
  group SPL
    ../SPL/: stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_rcc.h stm32f10x_sdio.h stm32f10x_dma.c stm32f10x_dma.h
  group CMSIS
    ../CMSIS/: core_cm3.c core_cm3.h stm32f10x.h stm32f10x_conf.h system_stm32f10x.c system_stm32f10x.h
  group Source
    ../Source/: sdio.c
  group SD
    ../SD/: sdcard.c sdcard.h
