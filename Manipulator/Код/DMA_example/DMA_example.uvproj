# Keil uVision project DMA_example.uvproj, settings and files
target F1_Template (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: F4_I2C
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD USE_FULL_ASSERT USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: .\sources;.\sources\CMSIS;.\sources\STM32F10x_StdPeriph_Lib_V3.5.0\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CMSIS
    ./sources/CMSIS/: core_cm3.c system_stm32f10x.c stm32f10x_conf.h startup_stm32f10x_md.s stm32f10x.h
  group Main
    ./sources/: main.c fput_debug.c
  group Std_Periph_Lib
    ./sources/STM32F10x_StdPeriph_Lib_V3.5.0/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_adc.c stm32f10x_usart.c stm32f10x_dma.c
  group Peripheral
    ./sources/uart/: uart.c
